# Keil uVision project 3X4 Matrix_keyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 3X4 Matrix_keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 3X4 matrix.c
